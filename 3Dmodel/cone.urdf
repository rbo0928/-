Commit message: 小三角錐

File: 3Dmodel/cone.urdf (robot description, URDF)
Before this commit: robot sketchup_model, 1 links, 0 joints
Links:
- link body: geometry collision mesh filename=cone.dae scale=1 1 1; visual mesh filename=cone.dae scale=1 1 1
